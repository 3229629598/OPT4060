# Keil uVision project opt4060.uvprojx, settings and files
target opt4060 (6240000::V6.24::ARMCLANG)
  device: STM32C071G8Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20005FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: opt4060 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32C071xx
  c include: ../Core/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc;../Drivers/STM32C0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32C0xx/Include;../Drivers/CMSIS/Include;../Code/Inc;../USB/Class/CDC/Inc;../USB/Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Application/MDK-ARM
    ./: startup_stm32c071xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usb.c stm32c0xx_it.c stm32c0xx_hal_msp.c
  group Drivers/STM32C0xx_HAL_Driver
    ../Drivers/STM32C0xx_HAL_Driver/Src/: stm32c0xx_hal.c stm32c0xx_hal_cortex.c stm32c0xx_hal_rcc.c stm32c0xx_hal_rcc_ex.c stm32c0xx_hal_flash.c stm32c0xx_hal_flash_ex.c stm32c0xx_hal_gpio.c stm32c0xx_hal_dma.c stm32c0xx_hal_dma_ex.c stm32c0xx_hal_pwr.c stm32c0xx_hal_pwr_ex.c stm32c0xx_hal_exti.c stm32c0xx_hal_i2c.c stm32c0xx_hal_i2c_ex.c stm32c0xx_hal_tim.c stm32c0xx_hal_tim_ex.c stm32c0xx_hal_pcd.c stm32c0xx_hal_pcd_ex.c stm32c0xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32c0xx.c
  group USB/Core
    ../USB/Core/Src/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group USB/Class/CDC
    ../USB/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
  group Apps
    ../Code/Src/: bringup.c data_process.c crc.c opt4060.c
software components: CMSIS:CORE 5.6.0
